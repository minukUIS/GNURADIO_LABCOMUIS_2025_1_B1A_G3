options:
  parameters:
    generate_options: qt_gui
    id: Lab_comu_I
    output_language: python
    title: Primer Flujograma
  states: {}

blocks:
- name: amplitude
  id: variable_qtgui_range
  parameters:
    label: Amplitude
    start: '0'
    step: '100e-3'
    stop: '50'
    value: '1'
  states: {}
- name: frequency
  id: variable_qtgui_range
  parameters:
    label: frequency in Hz
    start: '0'
    step: '100'
    stop: 1e4
    value: 1e3
    widget: slider
  states: {}
- name: offset
  id: variable_qtgui_range
  parameters:
    label: offset
    start: '-5'
    step: '100e-3'
    stop: '5'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: variable_0
  id: variable
  parameters:
    value: '0'
  states: {}
- name: waveform
  id: variable_qtgui_chooser
  parameters:
    label: waveform
    labels: '["Constant", "Sine", "Cosine", "Square", "Triangle", "Saw Tooth"]'
    num_opts: '0'
    options: '[100, 101, 102, 103, 104, 105]'
    type: raw
    value: '102'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: amplitude
    freq: frequency
    offset: offset
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: waveform
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle2_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: v3.10.11.0-89-ga17f69e7
