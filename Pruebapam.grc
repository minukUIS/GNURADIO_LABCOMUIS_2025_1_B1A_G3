options:
  parameters:
    generate_options: qt_gui
    id: Pruebapam
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Am
  id: variable_qtgui_range
  parameters:
    label: amplitud mensaje
    start: '0'
    step: '0.1'
    stop: '10'
    value: '1'
  states: {}
- name: D
  id: variable_qtgui_range
  parameters:
    label: ancho pulso
    start: '0'
    step: '1'
    stop: '50'
    value: '10'
  states: {}
- name: fm
  id: variable_qtgui_range
  parameters:
    label: frecuencia mensaje
    start: '0'
    step: '10'
    stop: 10e3
    value: '10'
  states: {}
- name: fs
  id: variable_qtgui_range
  parameters:
    label: frecuencia pulsos
    start: '0'
    step: '1'
    stop: 10e3
    value: 1e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: ModulacionPAM_0
  id: ModulacionPAM
  parameters:
    D: D
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SQR_WAVE
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    nconnections: '2'
    type: float
    wintype: window.WIN_HAMMING
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '10000'
    srate: samp_rate
    type: float
    ymax: '10'
    ymin: '-10'
  states: {}

connections:
- [ModulacionPAM_0, '0', qtgui_freq_sink_x_0, '0']
- [ModulacionPAM_0, '0', qtgui_time_sink_x_0, '0']
- [analog_sig_source_x_0, '0', ModulacionPAM_0, '0']
- [analog_sig_source_x_0, '0', qtgui_freq_sink_x_0, '1']
- [analog_sig_source_x_0, '0', qtgui_time_sink_x_0, '1']

metadata:
  file_format: 1
  grc_version: v3.10.11.0-89-ga17f69e7
