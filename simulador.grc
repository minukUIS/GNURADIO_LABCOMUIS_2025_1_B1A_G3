options:
  parameters:
    generate_options: qt_gui
    id: Modulador_de_amplitud
    output_language: python
    title: Modulador de amplitud
  states: {}

blocks:
- name: AM
  id: variable_qtgui_range
  parameters:
    label: Amplitud mensaje
    start: '0'
    step: '100e-3'
    stop: '4'
    value: '1'
  states: {}
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: Amplitud portadora
    start: '0'
    step: '1e-3'
    stop: '1'
    value: '125e-3'
  states: {}
- name: FM
  id: variable_qtgui_range
  parameters:
    label: Frecuencia de mensaje
    start: '300'
    step: '100'
    stop: samp_rate/4
    value: 1e3
  states: {}
- name: Fc
  id: variable_qtgui_range
  parameters:
    label: Frecuencia portadora
    start: 50e6
    step: 1e6
    stop: 02.2e9
    value: 50e6
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: Ganacia transmisor
    start: '0'
    step: '1'
    stop: '30'
    value: '0'
  states: {}
- name: K
  id: variable_qtgui_range
  parameters:
    label: Habilita portadora
    start: '0'
    step: '1'
    stop: '1'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 12500000/8
  states: {}
- name: Modulador_Am_1
  id: Modulador_Am
  parameters:
    Ac: Ac
    Ka: K
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: AM
    freq: FM
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: Fc
    gain0: GTX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [Modulador_Am_1, '0', qtgui_freq_sink_x_0, '0']
- [Modulador_Am_1, '0', qtgui_time_sink_x_0, '0']
- [Modulador_Am_1, '0', uhd_usrp_sink_0, '0']
- [analog_sig_source_x_0, '0', Modulador_Am_1, '0']

metadata:
  file_format: 1
  grc_version: v3.10.11.0-89-ga17f69e7
